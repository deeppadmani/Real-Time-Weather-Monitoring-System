# Keil uVision project Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODAT2
  output: Final +hex
  c flags: Optimize=8 SizeSpeed=1
  group Application
    ./: main.c test.c
  group Drivers
    ./: UartDriver.c I2C_Driver.c DS1621_DeviceFrame.c DelayDriver.c MCP3204Driver.c LCD_Driver.c Ext_IntrruptDriver.c RTC_Driver.c
